# Keil uVision project Project.uvprojx, settings and files
target My Project (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,ARM_MATH_CM4
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\Libraries\STM32_USB_Device_Library\Core\Inc;..\Libraries\STM32_USB_Device_Library\Class\CDC\Inc;..\Libraries\FreeRTOS\include;..\Libraries\FreeRTOS\portable\RVDS\ARM_CM4F;..\Libraries\FreeRTOS\CMSIS_RTOS;..\Libraries\SEGGER_RTT;..\BSP;..\Code;..\USER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_sram.c
  group STM32F4xx_DSP
    ../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group STM32_USB_Library
    ../Libraries/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Libraries/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group FreeRTOS
    ../Libraries/FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../Libraries/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../Libraries/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
    ../Libraries/FreeRTOS/portable/MemMang/: heap_4.c
  group JLinkRTT
    ../Libraries/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_Printf.c SEGGER_RTT_Conf.h
  group BSP
    ../BSP/: BSP.c BSP_ADC.c BSP_LCD.c BSP_DAC.c BSP_MPU.c BSP_MPU_ex.c BSP_USB.c BSP_CODEC.c
  group Code
    ../Code/: stm32f4xx_hal_conf.h stm32f4xx_hal_msp.c stm32f4xx_it.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group USER
    ../USER/: main.cpp
